# Keil uVision project WuRenJi_EIDE.uvprojx, settings and files
target WuRenJi_EIDE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: WuRenJi_EIDE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Mid/FreeRTOS;../Mid/FreeRTOS/include;../Mid/FreeRTOS/Portable;../App;../Com/Inc;../Int/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Mid/FreeRTOS
    ../Mid/FreeRTOS/Source/: list.c tasks.c timers.c queue.c croutine.c stream_buffer.c event_groups.c
    ../Mid/FreeRTOS/Portable/: port.c heap_4.c
    ../Mid/FreeRTOS/: FreeRTOSConfig.h
  group App
    ../App/: App_Task.c App_Task.h App_Data.c App_Data.h App_Motor.c App_Motor.h
  group Com/Inc
    ../Com/Inc/: Com_debug.h Com_Types.h Com_Filter.h Com_IMU.h Com_PID.h
  group Com/Src
    ../Com/Src/: Com_debug.c Com_Filter.c Com_IMU.c Com_PID.c
  group Int/Inc
    ../Int/Inc/: Int_LED.h Int_Motor.h Int_SI24R1.h Int_MPU6050.h
  group Int/Src
    ../Int/Src/: Int_LED.c Int_Motor.c Int_SI24R1.c Int_MPU6050.c
software components: CMSIS:CORE 4.3.0
